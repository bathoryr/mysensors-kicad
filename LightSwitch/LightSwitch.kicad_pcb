# Repository bathoryr/mysensors-kicad

File README.md:

# KiCAD projects for mysensors
PCB designs for some MySensors devices.

## KiCad design LightSwitch/LightSwitch.kicad_pcb

Parts:
AC/DC1: HLK-PM01
C1: 1u; C_Disc_D5.0mm_W2.5mm_P5.00mm
C2: .1u; C_Disc_D5.0mm_W2.5mm_P5.00mm
C3: .1u; C_Disc_D5.1mm_W3.2mm_P5.00mm
C4: 10u; CP_Radial_D6.3mm_P2.50mm
C5: 47u; CP_Radial_D8.0mm_P2.50mm
F1: 0.5A; C_Disc_D8.0mm_W5.0mm_P7.50mm
J1: Door sensor; Pin_Header_Straight_1x02_Pitch2.54mm
J2: Light switch; bornier2_V
J3: AC input; bornier2_V
J4: Light bulb; bornier2_V
J5: PIR sensor; Pin_Header_Straight_1x03_Pitch2.54mm
R1: 10k; R_Axial_DIN0207_L6.3mm_D2.5mm_P10.16mm_Horizontal
R2: 560; R_Axial_DIN0207_L6.3mm_D2.5mm_P10.16mm_Horizontal
U1: ATMEGA328P-PU; DIP-28_W7.62mm_Socket
U2: NRF24L01
U3: G3MB-202P

Connections:
+3V3: AC/DC1.3 (+Vo), C1.2, C2.1, C3.1, C4.1, C5.2, J5.1, R1.1, U1.7 (VCC), U1.20 (AVCC), U2.2 (VCC)
/CE: U1.15 ((PCINT1/OC1A)PB1), U2.3 (CE)
/CSN: U1.16 ((PCINT2/OC1B/~SS~)PB2), U2.4 (CSN)
GND: AC/DC1.4 (-Vo), C1.1, C2.2, C3.2, C4.2, C5.1, J1.2, J2.2, J5.3, U1.8 (GND), U1.22 (GND), U2.1 (GND), U3.4
unnamed: AC/DC1.1 (AC), J3.1, U3.2
unnamed: AC/DC1.2 (AC), F1.2
unnamed: F1.1, J3.2, J4.2
unnamed: J1.1, U1.4 ((PCINT18/INT0)PD2)
unnamed: J2.1, U1.12 ((PCINT22/OC0A/AIN0)PD6)
unnamed: J4.1, U3.1
unnamed: J5.2, U1.5 ((PCINT19/OC2B/INT1)PD3)
unnamed: R1.2, U1.1 ((PCINT14/~RESET~)PC6)
unnamed: R2.1, U3.3
unnamed: R2.2, U1.13 ((PCINT23/AIN1)PD7)
unnamed: U1.17 ((PCINT3/OC2A/MOSI)PB3), U2.6 (MOSI)
unnamed: U1.18 ((PCINT4/MISO)PB4), U2.7 (MISO)
unnamed: U1.19 ((PCINT5/SCK)PB5), U2.5 (SCK)

Board: 2 copper layers, 55.9 x 48.4 mm, 17 parts (0 on the bottom side), 17 nets.

## KiCad design BoilerTemp/relay-module.kicad_pcb

Parts:
D2: 1N4000; Diode_DO-41_SOD81_Horizontal_RM10
P9: Input control; Pin_Header_Straight_1x03
P10: Output power; Emb3_5
Q1: 2N7000; TO-92_Molded_Narrow_Oval
R4: 10k; Resistor_Horizontal_RM10mm
RL1: FINDER-44.52; Relay_DPDT_Schrack-RT2_RM5mm

Connections:
GND: P9.1, Q1.1 (S), R4.2
unnamed: D2.1 (K), P9.3, RL1.A1
unnamed: D2.2 (A), Q1.3 (D), RL1.A2
unnamed: P9.2, Q1.2 (G), R4.1
unnamed: P10.1, RL1.12, RL1.22
unnamed: P10.2, RL1.11, RL1.21
unnamed: P10.3, RL1.14, RL1.24

Board: 2 copper layers, 53.5 x 38.7 mm, 6 parts (0 on the bottom side), 7 nets.

## KiCad design Triac/Triac.kicad_pcb

Board: 2 copper layers, 44.2 x 57.9 mm, 14 parts (0 on the bottom side), 10 nets.

Parts:
C1: 15n/400V; C_Disc_D12_P7.75
D1: LED; LED-3MM
HS1: HEATSINK; Heatsink_Fischer_SK129-STS_42x25mm_2xDrill2.5mm
M1, M2: MOUNTING-HOLE; MountingHole_3mm
P1: -Control+; Pin_Header_Straight_1x02
P2: IN AC230V; bornier2
P3: OUT AC230V/16A; bornier2
R1: 100R; Resistor_Horizontal_RM10mm
R2: 360R; Resistor_Horizontal_RM10mm
R3: 330R; Resistor_Horizontal_RM10mm
R4: 47R; Resistor_Horizontal_RM15mm
U1: MOC3041M; DIP-6_W7.62mm
U2: BTA16/800BRG; TO-220_Neutral123_Vertical

Connections:
/Data: P1.2, R1.2
/GND: P1.1, U1.2
/L: P2.1, R2.1, R4.1, U2.2
/NULL: P2.2, P3.2
unnamed: C1.1, R4.2
unnamed: C1.2, P3.1, R3.2, U2.1
unnamed: D1.1, U1.1
unnamed: D1.2, R1.1
unnamed: R2.2, U1.6
unnamed: R3.1, U1.4, U2.3

## KiCad design MyGateway/MyGateway.kicad_pcb

Parts:
C1: 10u; C_Radial_D5_L11_P2.5
P1: FTDI; Pin_Header_Straight_1x03
R1, R2, R3, R4, R6: 10k; Resistor_Horizontal_RM10mm
R5: 22k; Resistor_Horizontal_RM10mm
SW1: RESET BTN; SW_PUSH_SMALL
SW2: FLASH BTN; SW_PUSH_SMALL
U1: ESP-12E
U2: nRF24L01+; NRF24L01+

Connections:
+3V3: R1.2, R2.2, R3.2, R6.2, U1.3 (CH_PD), U1.8 (VCC), U2.2 (VCC)
/CE: U1.19 (GPIO4), U2.3 (CE)
/CSN: U1.16 (GPIO15), U2.4 (CSN)
/MISO: U1.6 (GPIO12), U2.7 (MISO)
/MOSI: U1.7 (GPIO13), U2.6 (MOSI)
/RX: P1.1, U1.22 (TXD)
/SCK: U1.5 (GPIO14), U2.5 (SCK)
/TX: P1.2, R4.1
GND: P1.3, R5.2, SW1.2, SW2.2, U1.15 (GND), U2.1 (GND)
unnamed: C1.1, R1.1, U1.1 (REST)
unnamed: C1.2, R6.1, SW1.1
unnamed: R2.1, U1.17 (GPIO2)
unnamed: R3.1, SW2.1, U1.18 (GPIO0)
unnamed: R4.2, R5.1, U1.21 (RXD)

Board: 2 copper layers, 12 parts (1 on the bottom side), 14 nets.

## KiCad design MySensor/MySensor.kicad_pcb

Board: 2 copper layers, 69.8 x 52.1 mm, 24 parts (0 on the bottom side), 25 nets.

Parts:
C1, C5, C6, C7, C8, C9: 100n; C_Disc_D3_P2.5
C2: 10u; C_Radial_D5_L6_P2.5
C3, C4: 22p; C_Disc_D3_P2.5
DISPLAY1: PCD8544; Socket_Strip_Straight_1x08
IC1: ATMEGA328P-P; DIP-28_W7.62mm
P1: Batt; Pin_Header_Angled_1x02
P2: NRF24L01+; Pin_Header_Straight_2x04
P3: FTDI; Pin_Header_Straight_1x04
P4: DHT22; Pin_Header_Angled_1x04
P5: PINOUT; Pin_Header_Straight_1x06
R1, R2, R5: 10k; Resistor_Horizontal_RM10mm
R3: 1M; Resistor_Horizontal_RM10mm
R4: 270K; Resistor_Horizontal_RM10mm
SW1: RESET BTN; SW_PUSH_SMALL
U1: MCP1702; TO-92_Molded_Narrow
Y1: 16M; HC-49V

Connections:
+3V3: C2.1, C8.1, C9.1, DISPLAY1.1, IC1.7, IC1.20, P2.7, P4.1, P5.5, R1.1, R5.2, U1.3
/A0: C6.1, IC1.23, R3.2, R4.1
/A1: IC1.24, P5.1
/CE: IC1.15, P2.6
/CS: IC1.16, P2.5
/D2: IC1.4, P5.4
/D3: IC1.5, P5.3
/D8: IC1.14, P5.2
/D/C: DISPLAY1.5, IC1.6
/DIN: DISPLAY1.6, IC1.11
/MISO: IC1.18, P2.2
/MOSI: IC1.17, P2.3
/RESET: C5.1, P3.1
/RST: C5.2, DISPLAY1.4, IC1.1, R1.2, SW1.1
/RX: IC1.3, P3.2
/SCK: IC1.19, P2.4
/SCLK: DISPLAY1.7, IC1.12
/TX: P3.3, R2.1
GND: C1.2, C2.2, C3.1, C4.1, C6.2, C7.2, C8.2, C9.2, DISPLAY1.2, DISPLAY1.3, IC1.8, IC1.22, P1.1, P2.8, P3.4, P4.4, P5.6, R4.2, SW1.2, U1.1
unnamed: C1.1, P1.2, R3.1, U1.2
unnamed: C3.2, IC1.9, Y1.1
unnamed: C4.2, IC1.10, Y1.2
unnamed: C7.1, IC1.21
unnamed: IC1.2, R2.2
unnamed: IC1.13, P4.2, R5.1

## KiCad design FreezerSensor/FreezerSensor.kicad_pcb

Parts:
C1: 1u; C_Disc_D3_P2.5
C2: 10u; C_Radial_D8_L13_P3.8
C3, C4, C5: 100n; C_Disc_D6_P5
IC1: ATMEGA328P-P; DIP-28_W7.62mm
LIGHGT1: BH1750; Socket_Strip_Straight_1x05
P1: FTDI; Pin_Header_Straight_1x04
P2: CONN_01X02; Pin_Header_Straight_1x02
R1, R2: 10k; Resistor_Vertical_RM5mm
R3: 4k7; Resistor_Vertical_RM5mm
SW1: SW_PUSH; SW_TH_Tactile_Omron_B3F-10xx
U1: MCP1702-3.3; TO-92_Inline_Narrow_Oval
U2: nRF24L01+; NRF24L01+
U3: DS18B20; TO-92_Inline_Narrow_Oval

Connections:
+3V3: C2.1, C3.1, C4.1, IC1.7 (VCC), IC1.20 (AVCC), LIGHGT1.5, R1.2, R3.1, U1.3 (VO), U2.2 (VCC), U3.3 (VDD)
/CE: IC1.9 ((PCINT6/XTAL1/TOSC1)PB6), U2.3 (CE)
/CSN: IC1.10 ((PCINT7/XTAL2/TOSC2)PB7), U2.4 (CSN)
/MISO: IC1.18 ((PCINT4/MISO)PB4), U2.7 (MISO)
/MOSI: IC1.17 ((PCINT3/OC2A/MOSI)PB3), U2.6 (MOSI)
/RESET: C5.2, IC1.1 ((PCINT14/~RESET~)PC6), R1.1, SW1.1
/RX: IC1.3 ((PCINT17/TXD)PD1), P1.2
/SCK: IC1.19 ((PCINT5/SCK)PB5), U2.5 (SCK)
/SCL: IC1.28 ((PCINT13/SCL/ADC5)PC5), LIGHGT1.4
/SDA: IC1.27 ((PCINT12/SDA/ADC4)PC4), LIGHGT1.3
/TX: IC1.2 ((PCINT16/RXD)PD0), R2.2
GND: C1.2, C2.2, C3.2, C4.2, IC1.8 (GND), IC1.22 (GND), LIGHGT1.1, LIGHGT1.2, P1.4, P2.1, SW1.2, U1.1 (GND), U2.1 (GND), U3.1 (GND)
unnamed: C1.1, P2.2, U1.2 (VI)
unnamed: C5.1, P1.1
unnamed: IC1.13 ((PCINT23/AIN1)PD7), R3.2, U3.2 (DQ)
unnamed: P1.3, R2.1

Board: 2 copper layers, 15 parts (0 on the bottom side), 16 nets.

## KiCad design LEDLight/LEDLight.kicad_pcb

Parts:
C1, C2: 10u; C_Radial_D5_L11_P2.5
D1: LED Test; LED-3MM
D2: LED Move; LED-3MM
P1: LED Light; Pin_Header_Straight_1x02_Pitch3.96mm_Friction_Lock
P2: PIR Sensor; Pin_Header_Straight_1x03
P3: RF433 Receiver; Pin_Header_Straight_1x04
P4: Light Sensor; Pin_Header_Straight_1x04
P5: INPUT voltage 12V; Pin_Header_Straight_1x02_Pitch3.96mm_Friction_Lock
P6: Thermo drive; Pin_Header_Straight_1x02_Pitch3.96mm_Friction_Lock
Q1, Q2: IRLZ44N; TO-220
R1: 330R; Resistor_Vertical_RM5mm
R2: 330R; Resistor_Horizontal_RM10mm
R3: 4K7; Resistor_Vertical_RM5mm
U1: arduino_NANO; arduino_mini
U2: nRF24L01+; NRF24L01
U3: DS18B20; TO-92_Inline_Narrow_Oval

Connections:
/3V3: C1.1, P4.1, R3.1, U1.2 (3V3), U2.2 (VCC), U3.3 (VDD)
/5V: C2.1, P2.1, P3.1, U1.12 (5V)
/CE: U1.27 (#D9), U2.3 (CE)
/CSN: U1.28 ((SS)#D10), U2.4 (CSN)
/MISO: U1.30 ((MISO)D12), U2.7 (MISO)
/MOSI: U1.29 ((MOSI)#D11), U2.6 (MOSI)
/PIRD: P2.2, U1.22 (D4)
/RFd: P3.2, P3.3, U1.20 ((int2)D2)
/SCK: U1.1 ((led)(SCK)D13), U2.5 (SCK)
/SCL: P4.2, U1.9 (A5(SCL))
/SDA: P4.3, U1.8 (A4(SDA))
/TEMP: R3.2, U1.26 (D8), U3.2 (DQ)
GND: C1.2, C2.2, D1.1 (K), D2.1 (K), P2.3, P3.4, P4.4, P5.2, Q1.3 (S), Q2.3 (S), U1.14 (GND), U1.19 (GND), U2.1 (GND), U3.1 (GND)
unnamed: D1.2 (A), R2.1
unnamed: D2.2 (A), R1.1
unnamed: P1.2, Q1.2 (D)
unnamed: P6.2, Q2.2 (D)
unnamed: Q1.1 (G), U1.23 (#D5)
unnamed: Q2.1 (G), U1.24 (#D6)
unnamed: R1.2, U1.25 (D7)
unnamed: R2.2, U1.21 ((int3)#D3)
VCC: P1.1, P5.1, P6.1, U1.15 (Vin)

Board: 2 copper layers, 50.2 x 65.4 mm, 18 parts (0 on the bottom side), 22 nets.

## KiCad design HDOSensor/HDOSensor.kicad_pcb

Parts:
C2: 10M; C_Radial_D5_L11_P2.5
C3, C4, C5: 100n; C_Disc_D3_P2.5
C6: 4M7; C_Radial_D5_L11_P2.5
C7, C8: 22p; C_Disc_D3_P2.5
IC1: ATMEGA328P-P; DIP-28_W7.62mm
P1: HDO switch; Pin_Header_Straight_1x02
P2: FTDI; Pin_Header_Straight_1x04
P3: Power supp; Pin_Header_Straight_1x02
P4: Photo sensor; Pin_Header_Angled_1x02
P5: Photo sensor; Pin_Header_Straight_1x02
Q1: BPX81; Pin_Header_Straight_1x02
R1: 220k; Resistor_Horizontal_RM10mm
R2: 10k; Resistor_Horizontal_RM10mm
R3: 10k; Resistor_Vertical_RM5mm
SW1: SW_PUSH; SW_PUSH_SMALL
U1: 74HC14; DIP-14_W7.62mm
U3: NCP1117ST33T3G; SOT-223
U4: nRF24L01+; NRF24L01+
Y1: 16MHz; Crystal_HC49-U_Vertical

Connections:
+5V: C2.1, C3.1, C4.1, IC1.7 (VCC), IC1.20 (AVCC), P3.2, R1.1, R2.1, R3.1, U1.14 (VCC), U3.3 (VI)
/CE: IC1.15 ((PCINT1/OC1A)PB1), U4.3 (CE)
/CSN: IC1.16 ((PCINT2/OC1B/~SS~)PB2), U4.4 (CSN)
/MISO: IC1.18 ((PCINT4/MISO)PB4), U4.7 (MISO)
/MOSI: IC1.17 ((PCINT3/OC2A/MOSI)PB3), U4.6 (MOSI)
/RST: C5.2, P2.1
/RX: IC1.3 ((PCINT17/TXD)PD1), P2.2
/SCK: IC1.19 ((PCINT5/SCK)PB5), U4.5 (SCK)
/TX: IC1.2 ((PCINT16/RXD)PD0), P2.3
GND: C2.2, C3.2, C4.2, C6.2, C7.2, C8.2, IC1.8 (GND), IC1.22 (GND), P1.1, P2.4, P3.1, P5.1, SW1.2, U1.7 (GND), U3.1 (GND), U4.1 (GND)
unnamed: C5.1, IC1.1 ((PCINT14/~RESET~)PC6), R2.2, SW1.1
unnamed: C6.1, U3.2 (VO), U4.2 (VCC)
unnamed: C7.1, IC1.10 ((PCINT7/XTAL2/TOSC2)PB7), Y1.2
unnamed: C8.1, IC1.9 ((PCINT6/XTAL1/TOSC1)PB6), Y1.1
unnamed: IC1.4 ((PCINT18/INT0)PD2), U1.2
unnamed: IC1.5 ((PCINT19/OC2B/INT1)PD3), U1.4
unnamed: P1.2, R3.2, U1.3
unnamed: P4.1, Q1.1 (E)
unnamed: P4.2, Q1.2 (C)
unnamed: P5.2, R1.2, U1.1

Board: 2 copper layers, 84.1 x 39.6 mm, 22 parts (2 on the bottom side), 20 nets.

## Commit log

2018-05-05 Initial upload
2018-12-06 Added Doorbell switch, upgraded Kicad to v5
2022-01-28 LightSwitch changes
2022-01-28 Added gitignore
